Commit message: added limits to waist joint

File: urdf/robot_3.urdf (robot description, URDF)
Before this commit: robot edwin, 7 links, 6 joints
Joints:
- joint waist: limit (none) -> lower=-3.1 upper=3.1 effort=1000.0 velocity=0.5; type continuous -> revolute
